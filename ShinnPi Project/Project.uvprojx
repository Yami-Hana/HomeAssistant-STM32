# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\STM32F10x_StdPeriph_Driver\inc;.\USER;.\USER\ins;.\USER\FATFS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group USER
    ./USER/: stm32f10x_it.c
    ./USER/led/: bsp_led.c
    ./USER/usart/: bsp_usart.c bsp_esp8266.c
    ./USER/sdio/: bsp_sdio_sdcard.c
    ./USER/lcd/: bsp_ili9341_lcd.c
    ./USER/font/: fonts.c
    ./USER/src/: main.c tim.c mqtt.c nvic.c steering.c key.c fire.c rain.c led.c shake.c
    ./USER/flash/: bsp_spi_flash.c
    ./USER/dht11/: bsp_dht11.c
    ./USER/sr501/: bsp_exti.c
    ./USER/ldr/: bsp_ldr.c
    ./USER/beep/: bsp_beep.c
  group FatFs
    ./USER/FATFS/: diskio.c ff.c
    ./USER/FATFS/option/: syscall.c ccsbcs.c
  group jpgLib
    ./USER/tjpgd/src/: jpgPort.c tjpgd.c
  group LIB
    ./STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_wwdg.c
